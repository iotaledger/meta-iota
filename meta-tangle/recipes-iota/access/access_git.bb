SUMMARY = "IOTA Access."
DESCRIPTION = "IOTA Access is a framework for decentralized access control."
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://${COMMON_LICENSE_DIR}/Apache-2.0;md5=89aea4e17d99a7cacdbeed46a0096b10"

SRC_URI = "git://git@github.com/iotaledger/frost.git;protocol=ssh"
SRCREV = "${AUTOREV}"

S = "${WORKDIR}/git/embedded"
