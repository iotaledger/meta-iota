DESCRIPTION = "A Wayland honeycombOS image"
LICENSE = "MIT"

require recipes-core/images/core-image-base.bb
