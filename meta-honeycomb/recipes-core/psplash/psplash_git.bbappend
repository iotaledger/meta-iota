FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SPLASH_IMAGES = "file://splash-img.h;outsuffix=default"
